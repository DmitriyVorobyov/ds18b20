# IAR project ds18b20.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group library
    ./: ds18b20.c ds18b20.h eight-segment_display.c eight-segment_display.h rfm22.c rfm22.h
  group stm8s_library
    ./: delay.c delay.h stm8s.h stm8s_clk.c stm8s_clk.h stm8s_one-wire.c stm8s_one-wire.h stm8s_spi.c stm8s_spi.h stm8s_uart2.c stm8s_uart2.h
